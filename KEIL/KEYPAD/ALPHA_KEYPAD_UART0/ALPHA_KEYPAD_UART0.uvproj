# Keil uVision project ALPHA_KEYPAD_UART0.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2129 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: NUM_KEYPAD +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s ALPHA_KEYPAD_UART0.c
    ../../LCD/: LCD.c
    ../../UART0/: UART0.c
    C:/Keil/ARM/INC/Philips/: delay.c
